# Keil uVision project wdog_demo.uvprojx, settings and files
target wdog_demo (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: GM6621LQFP64 Generic
  pack: Keil.GM66xx_DFP.1.4.1
  cpu: IROM(0x00000000,0x10000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: wdog_demo
  AfterMake: fromelf -c  ./objects/wdog_demo.axf -o ./objects/wdog_demo.dis
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..;..\..\..\..\..\inc;..\..\..\..\..\inc\drv\cmsis
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group prj
    ../../: wdog_demo.c
  group arch
    ../../../../../drv/arch/arm/: sysinit.c systick.c
  group common
    ../../../../../lib/common/: common.c printf.c
  group drv
    ../../../../../drv/dev/wdog/: wdog.c
    ../../../../../drv/dev/uart/: uart.c
    ../../../../../drv/dev/dma/: dma.c
    ../../../../../drv/dev/clock/: clock.c
    ../../../../../drv/dev/gpio/: gpio.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0

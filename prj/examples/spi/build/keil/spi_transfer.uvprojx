# Keil uVision project spi_transfer.uvprojx, settings and files
target spi_transfer Debug (ARM-ADS)
  device: GM6621LQFP64 Generic
  pack: Keil.GM66xx_DFP.1.3.9
  cpu: IROM(0x00000000,0x10000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: spi_transfer
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: KEIL
  c include: ..\..;..\..\..\..\..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group prj
    ../../: spi_transfer.c
  group lib
    ../../../../../lib/common/: common.c printf.c
  group drv
    ../../../../../drv/dev/spi/: spi.c
    ../../../../../drv/dev/clock/: clock.c
    ../../../../../drv/dev/gpio/: gpio.c
    ../../../../../drv/dev/dma/: dma.c
    ../../../../../drv/dev/uart/: uart.c
  group arch
    ../../../../../drv/arch/arm/: sysinit.c systick.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0

# Keil uVision project lcd_example.uvprojx, settings and files
target lcd_example (ARM-ADS)
  device: GM6601LQFP64 GreeMicroelectronics
  pack: Keil.GM66xx_DFP.1.0.0
  cpu: IROM(0x00000000,0x10000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: lcd_example
  c flags: Optim=3 OneElfS=1 wLevel=2
  c include: ..\..\..\lcd;..\..\..\..\..\inc;..\..\..\..\..\inc\drv\cmsis
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group prj
    ../../: lcd_example.c
  group arch
    ../../../../../drv/arch/arm/: sysinit.c systick.c
  group common
    ../../../../../lib/common/: common.c
  group drv
    ../../../../../drv/dev/lcd/: lcd.c
    ../../../../../drv/dev/gpio/: gpio.c
    ../../../../../drv/dev/clock/: clock.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0

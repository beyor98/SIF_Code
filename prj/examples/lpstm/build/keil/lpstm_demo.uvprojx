# Keil uVision project lpstm_demo.uvprojx, settings and files
target lpstm_demo (ARM-ADS)
  device: GM6621LQFP64 Generic
  pack: Keil.GM66xx_DFP.1.3.8
  cpu: IROM(0x00000000,0x10000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: lptim_test
  c flags: Optim=3 OneElfS=1 wLevel=2
  c include: ..\..\..\lpstm;..\..\..\..\..\inc\drv\dev;..\..\..\..\..\inc\drv\cmsis;..\..\..\..\..\drv\dev;..\..\..\..\..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group prj
    ../../: lpstm_demo.c
  group arch
    ../../../../../drv/arch/arm/: sysinit.c systick.c startup_gm6621.s
  group common
    ../../../../../lib/common/: common.c printf.c
  group drv
    ../../../../../drv/dev/clock/: clock.c
    ../../../../../drv/dev/dma/: dma.c
    ../../../../../drv/dev/gpio/: gpio.c
    ../../../../../drv/dev/lptim/: lptim.c
    ../../../../../drv/dev/etm/: etm.c
    ../../../../../drv/dev/rtc/: rtc.c
    ../../../../../drv/dev/uart/: uart.c
software components: CMSIS:CORE 3.40.0

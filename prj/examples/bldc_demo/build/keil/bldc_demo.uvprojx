# Keil uVision project bldc_demo.uvprojx, settings and files
target bldc_demo (ARM-ADS)
  device: GM6611LQFP100 Generic
  pack: Keil.GM66xx_DFP.1.3.5
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: bldc_demo
  c flags: Optim=3 OneElfS=1 wLevel=2
  c include: ..\..\..\bldc_demo;..\..\..\..\..\inc;..\..\..\..\..\inc\drv\cmsis
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group prj
    ../../: bldc_demo.c motor_control.c
  group arch
    ../../../../../drv/arch/arm/: sysinit.c systick.c
  group common
    ../../../../../lib/common/: common.c
  group drv
    ../../../../../drv/dev/adc/: adc.c
    ../../../../../drv/dev/clock/: clock.c
    ../../../../../drv/dev/dma/: dma.c
    ../../../../../drv/dev/etm/: etm.c
    ../../../../../drv/dev/gpio/: gpio.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0

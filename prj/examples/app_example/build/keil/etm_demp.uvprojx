# Keil uVision project etm_demp.uvprojx, settings and files
target etm_example (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: GM6612XDPC Generic
  pack: Keil.GM66xx_DFP.1.4.4
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: etm_example
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\etm;..\..\..\..\..\inc;..\..\..\..\..\drv\dev
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group prj
    ../../: etm_demo.c
  group common
    ../../../../../lib/common/: common.c printf.c
  group arch
    ../../../../../drv/arch/arm/: sysinit.c systick.c
  group drv
    ../../../../../drv/dev/clock/: clock.c
    ../../../../../drv/dev/gpio/: gpio.c
    ../../../../../drv/dev/etm/: etm.c
    ../../../../../drv/dev/pes/: pes.c
    ../../../../../drv/dev/adc/: adc.c
    ../../../../../drv/dev/dma/: dma.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0

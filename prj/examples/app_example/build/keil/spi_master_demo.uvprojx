# Keil uVision project spi_master_demo.uvprojx, settings and files
target app_demo (ARM-ADS)
  device: GM6621LQFP64 Generic
  pack: Keil.GM66xx_DFP.1.3.9
  cpu: IROM(0x00000000,0x10000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: app_demo
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: KEIL
  c misc: --gnu
  c include: ..\..\..\..\..\inc;..\..\..\app_example
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group prj
    ../../: spi_master_demo.c
  group arch
    ../../../../../drv/arch/arm/: sysinit.c systick.c
  group common
    ../../../../../lib/common/: common.c printf.c
  group drv
    ../../../../../drv/dev/clock/: clock.c
    ../../../../../drv/dev/uart/: uart.c
    ../../../../../drv/dev/dma/: dma.c
    ../../../../../drv/dev/gpio/: gpio.c
    ../../../../../drv/dev/nvm/: flash.c
    ../../../../../drv/dev/spi/: spi.c
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.0

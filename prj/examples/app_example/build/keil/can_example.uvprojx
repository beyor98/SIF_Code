# Keil uVision project can_example.uvprojx, settings and files
target can_example (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: GM6611BLQFP100 Generic
  pack: Keil.GM66xx_DFP.1.3.9
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: can_example
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: KEIL
  c include: ..\..;..\..\..\..\..\inc;..\..\..\..\..\inc\drv\dev
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group prj
    ../../: can_demo.c
  group drv
    ../../../../../drv/dev/uart/: uart.c
    ../../../../../drv/dev/clock/: clock.c
    ../../../../../drv/dev/gpio/: gpio.c
    ../../../../../drv/dev/dma/: dma.c
    ../../../../../drv/dev/nvm/: flash.c
    ../../../../../drv/dev/can/: can.c
  group lib
    ../../../../../lib/common/: common.c printf.c
  group arch
    ../../../../../drv/arch/arm/: sysinit.c systick.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0

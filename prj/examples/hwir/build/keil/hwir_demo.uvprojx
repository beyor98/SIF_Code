# Keil uVision project hwir_demo.uvprojx, settings and files
target hwir_demo (ARM-ADS)
  device: GM6611LQFP100 Generic
  pack: Keil.GM66xx_DFP.1.3.5
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: hwir_demo
  AfterMake: fromelf -c  ./objects/hwir_demo.axf -o ./objects/hwir_demo.dis
  c flags: Optim=3 OneElfS=1 wLevel=2
  c include: ..\..;..\..\..\..\..\inc;..\..\..\..\..\inc\drv\cmsis
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group prj
    ../../: hwir_demo.c
  group arch
    ../../../../../drv/arch/arm/: sysinit.c systick.c
  group common
    ../../../../../lib/common/: common.c printf.c
  group drv
    ../../../../../drv/dev/uart/: uart.c
    ../../../../../drv/dev/dma/: dma.c
    ../../../../../drv/dev/clock/: clock.c
    ../../../../../drv/dev/gpio/: gpio.c
    ../../../../../drv/dev/hwir/: hwir.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0

# Keil uVision project lvd_demo.uvprojx, settings and files
target lvd_example Debug (ARM-ADS)
  device: F6601VCPCC Generic
  pack: Keil.GM66xx_DFP.1.4.6
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: lvd_example
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: KEIL
  c include: ..\..\..\..\..\inc;..\..\..\lvd
  asm define: KEIL
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group prj
    ../../: lvd_demo.c
  group arch
    ../../../../../drv/arch/arm/: systick.c sysinit.c
  group common
    ../../../../../lib/common/: common.c printf.c
  group drv
    ../../../../../drv/dev/lvd/: lvd.c
    ../../../../../drv/dev/gpio/: gpio.c
    ../../../../../drv/dev/clock/: clock.c
    ../../../../../drv/dev/uart/: uart.c
    ../../../../../drv/dev/dma/: dma.c
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0

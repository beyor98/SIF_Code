# Keil uVision project kbi_demo.uvprojx, settings and files
target kbi_demo (ARM-ADS)
  device: GM6621LQFP64 Generic
  pack: Keil.GM66xx_DFP.1.3.5
  cpu: IROM(0x00000000,0x10000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: kbi_demo
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\..\kbi;..\..\..\..\inc;..\..\..\..\drv\dev;..\..\..\..\drv\cmsis
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group prj
    ../: kbi_demo.c
  group arch
    ../../../../drv/arch/arm/: sysinit.c systick.c
  group common
    ../../../../lib/common/: common.c printf.c
  group drv
    ../../../../drv/dev/dma/: dma.c
    ../../../../drv/dev/gpio/: gpio.c
    ../../../../drv/dev/kbi/: kbi.c
    ../../../../drv/dev/uart/: uart.c
    ../../../../drv/dev/clock/: clock.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0

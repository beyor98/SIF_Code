# Keil uVision project cpu_clock.uvprojx, settings and files
target cpu_clock Debug (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: GM6601BLQFP64 Generic
  pack: Keil.GM66xx_DFP.1.3.9
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: cpu_clock
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: KEIL
  c include: ..\..\..\clock;..\..\..\..\..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group prj
    ../../: cpu_clock.c
  group arch
    ../../../../../drv/arch/arm/: sysinit.c systick.c
  group common
    ../../../../../lib/common/: common.c printf.c
  group drv
    ../../../../../drv/dev/clock/: clock.c
    ../../../../../drv/dev/uart/: uart.c
    ../../../../../drv/dev/dma/: dma.c
    ../../../../../drv/dev/gpio/: gpio.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0

# Keil uVision project etm_example.uvprojx, settings and files
target etm_example (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: EMF6601VCPCC Generic
  pack: Keil.EMxx_DFP.1.5.2
  cpu: IRAM(0x20000000,0x1800) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: etm_example
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\etm;..\..\..\..\..\inc;..\..\..\..\..\drv\dev
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group prj
    ../../: etm_pwm_example.c
  group common
    ../../../../../lib/common/: common.c printf.c
  group arch
    ../../../../../drv/arch/arm/: sysinit.c systick.c
  group drv
    ../../../../../drv/dev/clock/: clock.c
    ../../../../../drv/dev/gpio/: gpio.c
    ../../../../../drv/dev/etm/: etm.c
    ../../../../../drv/dev/pes/: pes.c
    ../../../../../drv/dev/adc/: adc.c
    ../../../../../drv/dev/dma/: dma.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0

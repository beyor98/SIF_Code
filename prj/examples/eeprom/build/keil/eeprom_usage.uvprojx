# Keil uVision project eeprom_usage.uvprojx, settings and files
target eeprom (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: GM6611LQFP100 GreeMicroelectronics
  pack: Keil.GM66xx_DFP.1.3.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: eeprom_usage
  AfterMake: fromelf -c .\objects\eeprom_usage.axf -o .\objects\eeprom_usage.dis
  AfterMake: fromelf --bin --output=.\objects\eeprom_usage.bin .\objects\eeprom_usage.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\..\inc;..\..\..\eeprom;..\..\..\..\..\inc\drv\cmsis
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group prj
    ../../: eeprom_usage.c
  group arch
    ../../../../../drv/arch/arm/: sysinit.c systick.c
  group drv
    ../../../../../drv/dev/eeprom/: eeprom.c
    ../../../../../drv/dev/nvm/: flash.c
    ../../../../../drv/dev/uart/: uart.c
    ../../../../../drv/dev/dma/: dma.c
    ../../../../../drv/dev/clock/: clock.c
    ../../../../../drv/dev/gpio/: gpio.c
  group common
    ../../../../../lib/common/: common.c printf.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0

# Keil uVision project ucosii_demo.uvprojx, settings and files
target ucosii_demo (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: GM6611BLQFP100 Generic
  pack: Keil.GM66xx_DFP.1.3.9
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ucos_demo
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..;..\..\..\..\..\inc;..\..\..\..\..\inc\drv\cmsis;..\..;..\..\..\..\..\ucosii\ports;..\..\..\..\..\ucosii\source;..\..\..\..\..\inc\drv\arch
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group prj
    ../../: ucosii_demo.c includes.h os_cfg.h
  group arch
    ../../../../../drv/arch/arm/: sysinit.c systick.c
  group common
    ../../../../../lib/common/: common.c printf.c
  group drv
    ../../../../../drv/dev/uart/: uart.c
    ../../../../../drv/dev/dma/: dma.c
    ../../../../../drv/dev/clock/: clock.c
    ../../../../../drv/dev/gpio/: gpio.c
  group ucosii_port
    ../../../../../ucosii/ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group ucosii_source
    ../../../../../ucosii/source/: OS_CORE.C OS_FLAG.C OS_MBOX.C OS_MEM.C OS_MUTEX.C OS_Q.C OS_SEM.C OS_TASK.C OS_TIME.C README.txt uCOS_II.H
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0

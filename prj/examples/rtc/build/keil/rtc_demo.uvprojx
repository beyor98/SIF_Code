# Keil uVision project rtc_demo.uvprojx, settings and files
target rtc_demo (ARM-ADS)
  device: GM6621LQFP44 Generic
  pack: Keil.GM66xx_DFP.1.3.9
  cpu: IROM(0x00000000,0x10000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: rtc_demo +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c misc: --c99  --diag_suppress=177 --diag_suppress=61 --diag_suppress=68 --diag_suppress=111
  c include: ..\..\;..\..\..\..\..\inc;..\.\..\..\..\inc\drv\cmsis
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group prj
    ../../: rtc_demo.c
    ../../../../../drv/dev/rtc/: rtc.c
  group arch
    ../../../../../drv/arch/arm/: sysinit.c systick.c
  group common
    ../../../../../lib/common/: common.c printf.c
  group drv
    ../../../../../drv/dev/uart/: uart.c
    ../../../../../drv/dev/clock/: clock.c
    ../../../../../drv/dev/dma/: dma.c
    ../../../../../drv/dev/gpio/: gpio.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0

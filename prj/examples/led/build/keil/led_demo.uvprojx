# Keil uVision project led_demo.uvprojx, settings and files
target led_demo (ARM-ADS)
  device: GM6601LQFP64 GreeMicroelectronics
  pack: Keil.GM66xx_DFP.1.0.0
  cpu: IROM(0x00000000,0x10000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: led_demo
  c flags: Optim=3 OneElfS=1 wLevel=2
  c include: ..\..\..\led;..\..\..\..\..\inc;..\..\..\..\..\inc\drv\cmsis
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group prj
    ../../: led_demo.c
  group arch
    ../../../../../drv/arch/arm/: sysinit.c systick.c
  group common
    ../../../../../lib/common/: common.c
  group drv
    ../../../../../drv/dev/clock/: clock.c
    ../../../../../drv/dev/gpio/: gpio.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0

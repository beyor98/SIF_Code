# Keil uVision project uart_transfer.uvprojx, settings and files
target Uart_Example Debug (ARM-ADS)
  device: GM6621LQFP64 Generic
  pack: Keil.GM66xx_DFP.1.3.9
  cpu: IROM(0x00000000,0x10000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: uart_transfer
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: KEIL
  c include: ..\..;..\..\..\..\..\inc;..\..\..\..\..\inc\drv\dev
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group prj
    ../../: uart_transfer.c config.h
  group drv
    ../../../../../drv/dev/uart/: uart.c
    ../../../../../drv/dev/clock/: clock.c
    ../../../../../drv/dev/gpio/: gpio.c
    ../../../../../drv/dev/dma/: dma.c
  group lib
    ../../../../../lib/common/: common.c printf.c
  group arch
    ../../../../../drv/arch/arm/: sysinit.c systick.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0

# Keil uVision project lpower_demo.uvprojx, settings and files
target powemode_demo (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: GM6614SDPC Generic
  pack: Keil.GM66xx_DFP.1.4.4
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: lpower_demo
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --gnu
  c include: ..\..\..\..\inc;..\..\..\..\inc\drv\cmsis;..\..\power_mode;..\..\..\..\inc\drv\dev
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group prj
    ../: lpower_demo.c
  group arch
    ../../../../drv/arch/arm/: sysinit.c systick.c
  group common
    ../../../../lib/common/: common.c printf.c
  group drv
    ../../../../drv/dev/dma/: dma.c
    ../../../../drv/dev/gpio/: gpio.c
    ../../../../drv/dev/uart/: uart.c
    ../../../../drv/dev/clock/: clock.c
    ../../../../drv/dev/rtc/: rtc.c
    ../../../../drv/dev/lpower/: lpower.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0

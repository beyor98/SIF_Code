# Keil uVision project gpio_example.uvprojx, settings and files
target gpio_example (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: F6608HCPCC Generic
  pack: Keil.GM66xx_DFP.1.4.6
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x1800) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: gpio_example
  c flags: Optim=3 OneElfS=1 wLevel=2
  c include: ..\..\..\gpio;..\..\..\..\..\inc;..\..\..\..\..\inc\drv\cmsis
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group prj
    ../../: main.c
  group arch
    ../../../../../drv/arch/arm/: sysinit.c systick.c
  group common
    ../../../../../lib/common/: common.c
  group drv
    ../../../../../drv/dev/clock/: clock.c
    ../../../../../drv/dev/gpio/: gpio.c
    ../../../../../drv/dev/etm/: etm.c
    ../../../../../drv/dev/dma/: dma.c
    ../../../../../drv/dev/uart/: uart.c
  group module
    ../../../../../drv/module/: etm_module.c gpio_module.c sif_module.c
  group lib
    ../../../../../lib/common/: printf.c
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.0

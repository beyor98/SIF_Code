# Keil uVision project dma_example.uvprojx, settings and files
target dma_example Debug (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: F6601VCPCC Generic
  pack: Keil.GM66xx_DFP.1.4.6
  cpu: IRAM(0x20000000,0x1800) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: dma_example
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: KEIL
  c include: ..\..\..\dma;..\..\..\..\..\inc
  asm define: KEIL
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group prj
    ../../: dma_example.c
  group arch
    ../../../../../drv/arch/arm/: sysinit.c systick.c
  group common
    ../../../../../lib/common/: common.c
  group dev
    ../../../../../drv/dev/clock/: clock.c
    ../../../../../drv/dev/dma/: dma.c
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0

# Keil uVision project i2c_intloop.uvprojx, settings and files
target i2c_intloop Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: GM6601LQFP64 GreeMicroelectronics
  pack: Keil.GM66xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: i2c_loop
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: KEIL
  c misc: --gnu
  c include: ..\..\..\i2c_intloop;..\..\..\..\..\..\inc
  asm define: KEIL
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group prj
    ../../: i2c_int.c
  group arch
    ../../../../../../drv/arch/arm/: sysinit.c systick.c
  group common
    ../../../../../../lib/common/: common.c
  group drv
    ../../../../../../drv/dev/clock/: clock.c
    ../../../../../../drv/dev/gpio/: gpio.c
    ../../../../../../drv/dev/i2c/: i2c.c
    ../../../../../../drv/dev/dma/: dma.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0

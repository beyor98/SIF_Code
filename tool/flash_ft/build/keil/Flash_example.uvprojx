# Keil uVision project Flash_example.uvprojx, settings and files
target flash_example Debug (ARM-ADS)
  device: GM6601LQFP64 GreeMicroelectronics
  pack: Keil.GM66xx_DFP.1.0.0
  cpu: IROM(0x00000000,0x10000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Flash_example
  AfterMake: fromelf -c .\objects\Flash_example.axf -o .\objects\Flash_example.dis
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: KEIL
  c include: ..\..\..\flash;..\..\..\..\..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0xc00
  memory RVCT9: RAM 0x20000c00 size 0x400
  scatter file: .\Objects\Flash_example.sct
  group prj
    ../../: Flash_FT.c
  group arch
    ../../../../drv/arch/arm/: startup_gm6601_ft_flash.s
